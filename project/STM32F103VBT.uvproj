# Keil uVision project STM32F103VBT.uvproj, settings and files
target RUN IN FLASH (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103VBT +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: ..\inc;..\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../startup/: startup_stm32f10x_md.s
  group Inc
    ../inc/: frequency_struct.h
  group Src
    ../source/: main.c
    ../lib/: system_stm32f10x.c
  group Lib
    ../lib/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c misc.c stm32f10x_it.c stm32f10x_tim.c stm32f10x_adc.c
target RUN IN RAM (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: STM32F103VBT
  c flags: Optim=1
  c include: ..\inc;..\inc
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x1000
